FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-fix-replace-find.pl-dependency-with-modern-API-call.patch"

