
FILESEXTRAPATHS_prepend := "${THISDIR}/busybox_1.22.1:"

SRC_URI += "file://busyboxunameprocessor.patch \
          "
