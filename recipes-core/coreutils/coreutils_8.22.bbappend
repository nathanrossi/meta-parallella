
FILESEXTRAPATHS_prepend := "${THISDIR}/coreutils-8.22:"

SRC_URI += "file://unameprocessor.patch \
          "
