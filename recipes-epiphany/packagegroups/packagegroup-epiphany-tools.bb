
SUMMARY = "Epiphany tools"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS_packagegroup-epiphany-tools = " \
		epiphany-tools \
		bash \
		"

